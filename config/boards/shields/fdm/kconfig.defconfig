## config/boards/shields/fdm/kconfig.shield
```kconfig
config SHIELD_FDM
   def_bool $(shields_list_contains, fdm_right)
   def_bool $(shields_list_contains, fdm_left)
```
